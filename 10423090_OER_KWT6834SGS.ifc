Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 4b306f04-459f-4dbb-99ba-ce443730b245, NumberOfSaves: 1]
File name: 0001
Time: 2024-08-19T08:46:09+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 10423090_OER_KWT6834SGS:36683400_OER_10423090_KWT6834SGS, (2)
In: Default
Type - Material: Výchozí Nový materiál(1), z_Miele_Design_Glass Black, z_Miele_Design_Steel_Chrom, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel, <Unnamed>, z_Miele_Design_Alusilver, Default New Material, Poche, z_Miele_Design_OBSW, z_Miele_Design_Glass
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 700 mm; Height: 1920 mm; Depth: 746 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 36683400_OER_10423090_KWT6834SGS; sets with these values: 2

# IfcDistributionPort, Port_361814_1
Description: Flow; FlowDirection: SOURCEANDSINK
